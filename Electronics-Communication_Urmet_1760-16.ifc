Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-02-21T14:53:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 14:53:58 2023 * Host: URD0938 * Database: C:\Users\DNLMRCUD\AppData\Local\Temp\{759D13C0-30AA-4334-A851-F8C7C876296D}\ifc * Database version: 5507 * Database creation date: Tue Feb 21 14:53:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 14:53:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 14:53:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm

# IfcBuildingElementProxy: Electronics -Communication_Urmet_1760-16, Electronics -Communication_Urmet_1760-16:Electronics -Communication_Urmet_1760-16:130789
In: Livello 1
Type - Classification: 1760/16 (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Electronics -Communication_Urmet_1760-16
Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
